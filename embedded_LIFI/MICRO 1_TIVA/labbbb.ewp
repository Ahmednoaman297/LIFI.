# IAR project labbbb.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: ADC.c ADC.h common_macros.h GPIO.c GPIO.h hw_nvic.h hw_types.h ICU.c ICU.h INTERRUPT.c INTERRUPT.h keypad.c keypad.h lcd.c lcd.h main.c startup_ewarm.c std_types.h systick.c systick.h tempadc.c tempadc.h timers.c timers.h tm4c123gh6pm.h UART.c UART.h ULTRASONIC.c ULTRASONIC.h
